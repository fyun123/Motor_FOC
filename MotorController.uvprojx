# Keil uVision project MotorController.uvprojx, settings and files
target STM32F446RET6 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MortorController
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 ARM_MATH_CM4 MBED_BUILD_TIMESTAMP=1567486712.43 TARGET_STM32F4 __ASSERT_MSG TARGET_NAME=NUCLEO_F446RE TARGET_RELEASE TARGET_STM32F446xE DEVICE_PORTINOUT=1 TARGET_FF_MORPHO DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO TARGET_RTOS_M4_M7 DEVICE_CAN=1 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 DEVICE_SERIAL=1 DEVICE_ANALOGIN=1 TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M TARGET_NUCLEO_F446RE USB_STM_HAL TARGET_STM32F446RE DEVICE_I2C=1 __CORTEX_M4 TARGET_CORTEX DEVICE_LOWPOWERTIMER=1 TARGET_STM TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TOOLCHAIN_ARM_STD __CMSIS_RTOS DEVICE_PWMOUT=1 DEVICE_SERIAL_ASYNCH=1 TARGET_FAMILY_STM32 DEVICE_SPI=1 __MBED__=1 DEVICE_SPISLAVE=1 DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 USBHOST_OTHER DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM
  c misc: --no_rtti --split_sections -c --apcs=interwork --no_depend_system_headers --md --gnu --cpu=Cortex-M4.fp.sp --preinclude=mbed_config.h
  c include: .\core\CAN;.\core\Calibration;.\config;.\core\DRV8323;.\utils\FastMath;.\utils\FastPWM;.\utils\FlashWriter;.\core\PositionSensor;.\utils\PreferenceWriter;.\mbed-dev;mbed-dev/cmsis;mbed-dev/cmsis/TARGET_CORTEX_M;mbed-dev/cmsis/TARGET_CORTEX_M/TOOLCHAIN_ARM;mbed-dev/drivers;mbed-dev/hal;mbed-dev/hal/storage_abstraction;mbed-dev/platform;mbed-dev/targets/TARGET_STM;mbed-dev/targets/TARGET_STM/TARGET_STM32F4;mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE;mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE;mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device;mbed-dev/targets/TARGET_STM/TARGET_STM32F4/device;.\hardware;.\core\Controller;.\core\PIDRegulator;.\core\CurrentSensor
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DUSB_STM_HAL,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device/TOOLCHAIN_ARM_STD/stm32f446xx.sct
  link misc: --show_full_path
  group Application
    ./: main.cpp
  group HardWare
    ./hardware/: hw_setup.cpp hw_setup.h
  group Config
    ./Config/: mbed_config.h
    Config/: current_controller_config.h hw_config.h motor_config.h user_config.h
  group Controller
    ./core/Controller/: Controller.cpp Controller.h CurrentController.cpp CurrentController.h SpeedController.cpp SpeedController.h
  group CurrentSensor
    ./core/CurrentSensor/: CurrentSensor.cpp CurrentSensor.h
  group PositionSensor
    ./core/PositionSensor/: PositionSensor.h PositionSensorMA730.cpp PositionSensorMA730.h
  group Calibration
    ./core/Calibration/: calibration.cpp calibration.h
  group DRV8323
    ./core/DRV8323/: DRV.cpp DRV.h
  group CAN
    ./core/CAN/: CAN_com.cpp CAN_com.h
  group PIDRegulator
    ./core/PIDRegulator/: PIDRegulator.cpp PIDRegulator.h
  group FastMath
    ./utils/FastMath/: FastMath.cpp FastMath.h math_ops.cpp math_ops.h LUT.h
  group FastPWM
    ./utils/FastPWM/: FastPWM_common.cpp FastPWM.h
    ./utils/FastPWM/Device/: FastPWM_STM_TIM_PinOut.cpp FastPWM_STM_TIM.cpp
  group FlashWriter
    ./utils/FlashWriter/: FlashWriter.cpp FlashWriter.h stm32f4xx_flash.c stm32f4xx_flash.h
  group PreferenceWriter
    ./utils/PreferenceWriter/: PrefrenceWriter.cpp PreferenceWriter.h
  group mbed-dev
    mbed-dev/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/: analogin_api.c analogout_device.c can_device.h common_objects.h device.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h
    mbed-dev/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_flash_api.c mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-dev/targets/TARGET_STM/: analogout_api.c can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_overrides.c mbed_rtx.h nvic_addr.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
    mbed-dev/cmsis/: arm_math.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed-dev/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device/: cmsis.h cmsis_nvic.h flash_data.h hal_tick.h stm32f446xx.h stm32f4xx.h system_stm32f4xx.h
    mbed-dev/cmsis/TARGET_CORTEX_M/TOOLCHAIN_ARM/: cmsis_armcc.h cmsis_armclang.h
    mbed-dev/cmsis/TARGET_CORTEX_M/: cmsis_compiler.h
    mbed-dev/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/device/: hal_init_pre.c stm32_hal_legacy.h stm32f4xx_hal.c stm32f4xx_hal.h stm32f4xx_hal_adc.c stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.c stm32f4xx_hal_can.h stm32f4xx_hal_cec.c stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.c stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.c stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.c stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.c stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.c stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.c stm32f4xx_hal_eth.h stm32f4xx_hal_flash.c stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.c stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.c stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.c stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.c stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.c stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.c stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.c stm32f4xx_hal_mmc.h stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nand.h stm32f4xx_hal_nor.c stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.c stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.c stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.c stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.c stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.c stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.c stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.c stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.c stm32f4xx_hal_spi.h stm32f4xx_hal_sram.c stm32f4xx_hal_sram.h stm32f4xx_hal_tim.c stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.c stm32f4xx_hal_uart.h stm32f4xx_hal_usart.c stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.c stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.c stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.c stm32f4xx_ll_crc.h stm32f4xx_ll_dac.c stm32f4xx_ll_dac.h stm32f4xx_ll_dma.c stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.c stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.c stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.c stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.c stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.c stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.c stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.c stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.c stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.c stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.c stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.c stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.c stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.c stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.c stm32f4xx_ll_tim.h stm32f4xx_ll_usart.c stm32f4xx_ll_usart.h stm32f4xx_ll_usb.c stm32f4xx_ll_usb.h stm32f4xx_ll_utils.c stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h system_stm32f4xx.c
    mbed-dev/: mbed.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/: objects.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE/: PeripheralNames.h PeripheralPins.c PinNames.h system_clock.c
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device/TOOLCHAIN_ARM_STD/: startup_stm32f446xx.s
